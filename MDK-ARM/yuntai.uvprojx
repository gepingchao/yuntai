# Keil uVision project yuntai.uvprojx, settings and files
target yuntai (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: yuntai
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc;      ../Drivers/STM32F1xx_HAL_Driver/Inc;      ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;      ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;      ../Middlewares/Third_Party/FreeRTOS/Source/include;      ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;      ../Drivers/CMSIS/Include;      ../Drivers/CMSIS/Device/ST/STM32F1xx/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_spi_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_uart.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_dma.c stm32f1xx_hal_rtc.c stm32f1xx_hal_gpio.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_cortex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c tasks.c queue.c list.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Application/User
    ../Src/: stm32f1xx_hal_msp.c spi.c stm32f1xx_hal_timebase_TIM.c usart.c tim.c freertos.c gpio.c rtc.c stm32f1xx_it.c main.c bsp.c cpu.c CRC.c flash.c httpd.c httpult.c iap.c key.c my_it.c printf.c save_data.c socket.c ult.c w5500.c w5500_driver.c wizchip_conf.c dma.c motor.c protocol.c communication.c db_flash.c
software components: CMSIS:CORE 4.1.0
